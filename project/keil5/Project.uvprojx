# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Project +hex (library)
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Start;.\Library;.\app;.\User;.\System;.\Hardware;.\dirve\Inc;.\device\RTC;.\device\button;.\device\delay;.\device\SDCard;.\device\VS1053;.\device\W25Q64;.\device\common;.\platform_config;.\FATFS
  asm include: ..\keil5
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group app
    ./app/: app_button.c app_button.h app_display_menu.c app_display_menu.h app_music_application.c app_music_application.h app_display_lrc.c app_display_lrc.h app_setTime.c app_setTime.h
  group device
    ./device/common/: com_type.h com_ringbuffer.c
    ./device/button/: dev_button_config.c dev_button.c
    ./device/W25Q64/: dev_w25q64.c
    ./device/SDCard/: sdio_sdcard.c spi_sdcard.c spi_sdcard.h
    ./device/VS1053/: spi_vs1053.c spi_vs1053.h
    ./device/RTC/: dev_RTC.c dev_RTC.h
  group drive
    ./dirve/Src/: drv_gpio.c drv_irq.c drv_partition.c drv_rcc.c drv_spi.c drv_sys.c drv_timer.c drv_usart.c drv_wdt.c
  group FatFs
    ./FATFS/: diskio.c diskio.h fatfs.c fatfs.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
  group system
    ./System/: Delay.c sys.c oled.c OLED_Data.c OLED_Data.h
  group platform_config
    ./platform_config/: platform_mcu_resource.h platform_partition_config.h
  group user
    ./User/: main.c main.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
